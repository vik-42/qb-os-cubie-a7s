# no window system on the board, render straight to kms
PACKAGECONFIG:cubie-a7s = "drm-gles2"
