SUMMARY = "Robot brain image for the Radxa Cubie A7S, dev variant: passwordless root and dnf, never ship this"

require cubie-a7s-image.bb
require recipes-core/images/cubie-a7s-image-dev.inc
