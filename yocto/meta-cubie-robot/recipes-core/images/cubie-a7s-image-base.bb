SUMMARY = "Minimal image for the Radxa Cubie A7S, no ROS"
LICENSE = "MIT"

require recipes-core/images/core-image-minimal.bb
require cubie-a7s-image-common.inc
